options:
  parameters:
    generate_options: qt_gui
    id: tds_rtl_tx_hackrf_rx
    output_language: python
    title: Transmit and capture a TDS signal with SDR hardware
  states: {}

blocks:
- name: alpha
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,1,1,1]'
    label: Alpha
    orient: Qt.Horizontal
    start: '0'
    step: '.05'
    stop: '1'
    value: '.9'
  states: {}
- name: center_freq_MHz
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,0,1,1]'
    label: Center frequency (MHz)
    orient: Qt.Horizontal
    start: '2.5'
    step: '0.1'
    stop: '5.5'
    value: '3'
  states: {}
- name: downsample
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/user/tds-tutorials/data/TDS_Part_1_chirp_compare_fs_2000000_samplesPerCycle_2_Tc_sec_5_complex64.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0406464c8235a454b
    bb_gain0: '20'
    freq0: center_freq_MHz*1e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq_MHz*1e6
    fftsize: 1024/1
    gui_hint: '[1,0,1,2]'
    name: Spectrogram of transmit (HackRF) and receive chirp (RTL-SDR)
    showports: 'True'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/downsample
    fc: '0'
    fftsize: '1024'
    gui_hint: '[2,0,1,2]'
    name: Frequency corresponding to target range
    showports: 'True'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: downsample
    interp: '1'
    taps: ''
    type: ccc
  states: {state: bypassed}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0,direct_samp=2
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: center_freq_MHz*1e6
    gain0: '20'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: alpha
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_file_source_0_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_file_source_0_0_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [rtlsdr_source_0, '0', blocks_sub_xx_0, '0']
- [rtlsdr_source_0, '0', single_pole_iir_filter_xx_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_0, '1']

metadata:
  file_format: 1
