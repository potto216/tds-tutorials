options:
  parameters:
    generate_options: qt_gui
    id: tds_audio_find_range
    output_language: python
    title: Find the range using an audio chirp
  states: {}

blocks:
- name: fs
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: interp_factor
  id: variable
  parameters:
    value: '10'
  states: {}
- name: update_time_sec
  id: variable_qtgui_range
  parameters:
    label: Update Time
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/user/tds-tutorials/data/audio_chirp_presentation.bin
    repeat: 'True'
    type: float
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/user/tds-tutorials/data/audio_collect_presentation.bin
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: fs
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,0,1,3
    label1: ''
    name: Chirp
    size: '1024'
    srate: fs
    type: float
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: fs*interp_factor
    fc: '0'
    fftsize: 128*4
    gui_hint: 1,0,1,3
    name: Chirp
    showports: 'True'
    type: float
    update_time: update_time_sec
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: fs*interp_factor
    fc: '0'
    fftsize: 128*64
    gui_hint: 4,0,1,3
    int_max: '50'
    int_min: '-80'
    name: Mixer output
    showports: 'True'
    type: float
    update_time: update_time_sec
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: interp_factor
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: interp_factor
    taps: ''
    type: fff
  states: {}

connections:
- [blocks_file_source_0_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_0_0_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
