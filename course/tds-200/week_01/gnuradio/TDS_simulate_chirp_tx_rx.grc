options:
  parameters:
    generate_options: qt_gui
    id: TDS_simulate_chirp_tx_rx
    output_language: python
    title: Simulate the TX and RX for a chirp signal
  states: {}

blocks:
- name: downsample
  id: variable
  parameters:
    value: '200'
  states: {}
- name: fs
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '10000'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '10000'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/user/tds-tutorials/data/TDS_Part_1_chirp_compare_fs_4000000_samplesPerCycle_4_complex64.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: fs
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,0,1,3
    label1: ''
    label2: ''
    name: Chirp
    size: '1024'
    srate: fs
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: fs
    fc: '0'
    fftsize: int(1024/32)
    gui_hint: 1,0,1,3
    name: Chirp
    showports: 'True'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: fs/downsample
    fc: '0'
    fftsize: 1024*4
    gui_hint: 4,0,1,3
    name: Chirp
    showports: 'True'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: downsample
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_delay_0, '0', blocks_add_xx_0, '0']
- [blocks_delay_0, '0', blocks_delay_0_0, '0']
- [blocks_delay_0_0, '0', blocks_add_xx_0, '1']
- [blocks_file_source_0_0_0, '0', blocks_delay_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']

metadata:
  file_format: 1
