options:
  parameters:
    description: Determine the delay between the RX on different SDRs
    generate_options: qt_gui
    id: sdr_rx_delay_compare
    output_language: python
    title: SDR RX delay compare
  states: {}

blocks:
- name: IF_freq_MHz
  id: variable
  parameters:
    value: '120'
  states: {}
- name: center_freq_MHz
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '2.5'
    step: '0.1'
    stop: '5.5'
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sample_delay
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1000'
    stop: 1e6
    value: '0'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(sample_delay)
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '10'
    dc_offset_mode0: '2'
    freq0: center_freq_MHz*1e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq_MHz*1e6*0
    fftsize: 1024/2
    showports: 'True'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    freq0: (center_freq_MHz+IF_freq_MHz)*1e6
    gain0: '20'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_delay_0, '0']
- [rtlsdr_source_0, '0', blocks_multiply_conjugate_cc_0, '0']

metadata:
  file_format: 1
