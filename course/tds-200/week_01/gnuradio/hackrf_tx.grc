options:
  parameters:
    generate_options: qt_gui
    id: hack_tx
    output_language: python
    title: hack_tx
  states: {}

blocks:
- name: center_freq_MHz
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '2.5'
    step: '0.1'
    stop: '5.5'
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/user/tds-tutorials/data/TDS_Part_1_chirp_compare_fs_2000000_samplesPerCycle_2_complex64.bin
    repeat: 'True'
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0406464c8235a454b
    bb_gain0: '20'
    freq0: center_freq_MHz*1e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    name: HackRF
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq_MHz*1e6
    fftsize: 1024/2
    name: HackRF
    showports: 'True'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_const_source_x_0, '0', osmosdr_sink_0, '0']
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_const_source_x_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_file_source_0_0_0, '0', osmosdr_sink_0, '0']
- [blocks_file_source_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
