options:
  parameters:
    generate_options: qt_gui
    id: TDS_simulate_chirp_compare
    output_language: python
    title: Compare sine waves to a TDS waveform
  states: {}

blocks:
- name: fs
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gnuradio/tds-tutorials/course/tds-200/week_01/data/make_chirp_for_GNURadio_conf_fs_2000000_Tc_sec_1.0_complex64.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: fs
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,3
    label1: ''
    label2: ''
    name: Two sine waves
    size: '1024'
    srate: fs
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: fs
    fc: '0'
    fftsize: '256'
    gui_hint: 0,0,1,3
    name: Chirp
    showports: 'True'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
