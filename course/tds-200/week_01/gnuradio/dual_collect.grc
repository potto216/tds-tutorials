options:
  parameters:
    generate_options: qt_gui
    id: dual_collect
    output_language: python
    title: Collect in direct sample and with an upconverter
  states: {}

blocks:
- name: center_freq_MHz
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1.5'
    step: '0.1'
    stop: '5'
    value: '3'
  states: {}
- name: center_freq_spy_rtl_MHz
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 124-1.5
    step: '0.1'
    stop: 124+5
    value: '124'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: rtl-tx.bin
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: rtl-rcv.bin
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '30'
    freq0: center_freq_spy_rtl_MHz*1e6
    gain0: '30'
    gain_mode0: 'True'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    args: rtl=1,direct_samp=2
    bb_gain0: '0'
    freq0: center_freq_MHz*1e6
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [rtlsdr_source_0, '0', blocks_file_sink_1, '0']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [rtlsdr_source_0_0, '0', blocks_file_sink_0, '0']
- [rtlsdr_source_0_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
