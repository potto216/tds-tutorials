options:
  parameters:
    generate_options: qt_gui
    id: rtl_ultrasound_single_up_converter
    output_language: python
    title: Capture signals using an upconverter and RTL-SDR
  states: {}

blocks:
- name: center_freq_MHz
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 124-1.5
    step: '0.1'
    stop: 124+5
    value: '124'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq_MHz*1e6
    fftsize: 1024/2
    showports: 'True'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '30'
    freq0: center_freq_MHz*1e6
    gain0: '30'
    gain_mode0: 'True'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
