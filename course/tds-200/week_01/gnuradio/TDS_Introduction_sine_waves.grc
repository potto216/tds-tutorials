options:
  parameters:
    comment: Please run the Jupyter notebook notebooks/TDS_Introduction-sine_waves.ipynb first.
    generate_options: qt_gui
    id: TDS_Introduction_sine_waves
    output_language: python
    title: TDS Introduction sine waves
  states: {}

blocks:
- name: fs
  id: variable
  parameters:
    value: '16000000'
  states: {}
- name: input_filename
  id: variable
  parameters:
    value: '''data/TDS_Introduction_sine_waves_complex64.bin'''
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      The data file is generated by the Jupyter notebook 
      "notebooks/TDS_Introduction-sine_waves.ipynb"
      Run this notebook FIRST to create the data file
      ../data/TDS_Introduction_sine_waves_complex64.bin
    file: util.get_datafilename(input_filename)
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: fs
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: fs
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: fs
    fc: '0'
    fftsize: 1024*2
    showports: 'True'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: util
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport os\n\ndef get_datafilename(datafilename_to_validate):\n  if not os.path.isfile(datafilename_to_validate):\n    print(f'Unable to find the data file {datafilename_to_validate}. Did you generate it with the notebook TDS_Introduction-sine_waves.ipynb?')\n    cwd = os.getcwd()\n    if not os.path.isdir('data'):\n      print(f'Could not find the data directory. gnuradio-companion should have been run from the root directory of the repository. The directory it was run from is {cwd}. Is this the root directory?')            \n    else:\n      print(f'The data directory exists and it appears where gnuradio-companion was run from {cwd} is the root directory of the repository. Verify the notebook script was run to generate the data file.')\n  return datafilename_to_validate\n  \n"
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
