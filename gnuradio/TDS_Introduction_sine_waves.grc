options:
  parameters:
    generate_options: qt_gui
    id: TDS_Introduction_sine_waves
    output_language: python
    title: TDS Introduction sine waves
  states: {}

blocks:
- name: fs
  id: variable
  parameters:
    value: '16000000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/user/Examples/tds-tutorials/gnuradio/TDS_Introduction_sine_waves_complex64.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: fs
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: fs
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: fs
    fc: '0'
    fftsize: 1024*2
    showports: 'True'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
