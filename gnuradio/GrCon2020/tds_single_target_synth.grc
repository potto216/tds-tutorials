options:
  parameters:
    generate_options: qt_gui
    id: tds_single_target_synth
    output_language: python
    title: TDS single target detection
  states: {}

blocks:
- name: delay_samples
  id: variable_qtgui_range
  parameters:
    label: Delay samples
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '10'
    stop: '20000'
    value: '10000'
  states: {}
- name: downsample
  id: variable
  parameters:
    value: '3'
  states: {}
- name: fs
  id: variable
  parameters:
    value: 4000000/400
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_2
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_2_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_2_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_2_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_3
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/user/tds-tutorials/data/TDS_Part_1_chirp_compare_fs_2000000_samplesPerCycle_2_complex64.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: Find the range to the target by subtracting the transmit chirp through mixing
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: fs
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: fs
    fc: '0'
    fftsize: 1024*2
    gui_hint: 0,0,2,2
    name: Spectrogram of transmit and receive chirp
    showports: 'True'
    type: complex
    update_time: '0.1'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: fs/downsample
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,2,2
    name: Frequency corresponding to target range
    showports: 'True'
    type: complex
    update_time: '0.0005'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: downsample
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_add_xx_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_delay_0, '0', blocks_delay_0_0, '0']
- [blocks_delay_0_0, '0', blocks_delay_0_0_2, '0']
- [blocks_delay_0_0_2, '0', blocks_delay_0_0_2_0, '0']
- [blocks_delay_0_0_2_0, '0', blocks_delay_0_1, '0']
- [blocks_delay_0_0_2_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_delay_0_0_2_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_delay_0_0_2_1, '0', blocks_delay_0_0_2_0_0, '0']
- [blocks_delay_0_0_3, '0', blocks_delay_0_0_2_1, '0']
- [blocks_delay_0_1, '0', blocks_delay_0_0_3, '0']
- [blocks_file_source_0_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_delay_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']

metadata:
  file_format: 1
