options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    comment: This is just the phase
    freq: '1'
    offset: '-0.5'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: sin
    type: float
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1, -1]'
    fftaps: '0.5'
    oldstyle: 'False'
    type: ffd
  states: {}
- name: iir_filter_xxx_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1, -1]'
    fftaps: '0.5'
    oldstyle: 'False'
    type: ffd
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', iir_filter_xxx_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0, '0', iir_filter_xxx_0_0, '0']
- [blocks_transcendental_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_transcendental_0, '0', qtgui_waterfall_sink_x_0, '0']
- [iir_filter_xxx_0, '0', blocks_throttle_0, '0']
- [iir_filter_xxx_0_0, '0', blocks_transcendental_0, '0']
- [iir_filter_xxx_0_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
