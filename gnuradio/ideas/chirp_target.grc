options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: delay_samples
  id: variable_qtgui_range
  parameters:
    label: Delay samples
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '10'
    stop: '20000'
    value: '10000'
  states: {}
- name: downsample
  id: variable
  parameters:
    value: '200'
  states: {}
- name: fs
  id: variable
  parameters:
    value: 4000000/400
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_0_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_1_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_2
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_0_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_0_1_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_0_1_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_0_1_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_0_2
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_0_2_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_0_3
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_1_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_1_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_1_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_1_0_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_1_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_1_1_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_1_2
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_2
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_2_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_2_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_2_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_3
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_3_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_4
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1_0_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1_0_0_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1_0_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1_0_1_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1_0_2
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1_1_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1_1_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1_1_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1_2
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1_2_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1_3
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_2_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_2_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_2_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_2_0_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_2_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_2_1_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_2_2
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_3
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_3_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_3_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_3_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_4
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_4_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_5
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/user/tds-tutorials/data/TDS_Part_1_chirp_compare_fs_4000000_samplesPerCycle_4_complex64.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: fs
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,0,1,3
    label1: ''
    label2: ''
    name: Chirp
    size: '1024'
    srate: fs
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: fs
    fc: '0'
    fftsize: 1024/1
    gui_hint: 1,0,1,3
    name: Chirp
    showports: 'True'
    type: complex
    update_time: '0.1'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: fs/downsample
    fc: '0'
    fftsize: 1024*4
    gui_hint: 4,0,1,3
    name: Chirp
    showports: 'True'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: downsample
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0_0, '0']
- [blocks_delay_0, '0', blocks_delay_0_0, '0']
- [blocks_delay_0_0, '0', blocks_delay_0_1, '0']
- [blocks_delay_0_0_0, '0', blocks_delay_0_2, '0']
- [blocks_delay_0_0_0_0, '0', blocks_delay_0_3, '0']
- [blocks_delay_0_0_0_0_0, '0', blocks_delay_0_4, '0']
- [blocks_delay_0_0_0_0_0_0, '0', blocks_delay_0_5, '0']
- [blocks_delay_0_0_0_0_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0_0_0_0_0_1, '0', blocks_delay_0_4_0, '0']
- [blocks_delay_0_0_0_0_1, '0', blocks_delay_0_3_0, '0']
- [blocks_delay_0_0_0_0_1_0, '0', blocks_delay_0_3_0_0, '0']
- [blocks_delay_0_0_0_0_2, '0', blocks_delay_0_3_1, '0']
- [blocks_delay_0_0_0_1, '0', blocks_delay_0_2_0, '0']
- [blocks_delay_0_0_0_1_0, '0', blocks_delay_0_2_0_0, '0']
- [blocks_delay_0_0_0_1_0_0, '0', blocks_delay_0_2_0_0_0, '0']
- [blocks_delay_0_0_0_1_1, '0', blocks_delay_0_2_0_1, '0']
- [blocks_delay_0_0_0_2, '0', blocks_delay_0_2_1, '0']
- [blocks_delay_0_0_0_2_0, '0', blocks_delay_0_2_1_0, '0']
- [blocks_delay_0_0_0_3, '0', blocks_delay_0_2_2, '0']
- [blocks_delay_0_0_1, '0', blocks_delay_0_1_0, '0']
- [blocks_delay_0_0_1_0, '0', blocks_delay_0_1_0_0, '0']
- [blocks_delay_0_0_1_0_0, '0', blocks_delay_0_1_0_0_0, '0']
- [blocks_delay_0_0_1_0_0_0, '0', blocks_delay_0_1_0_0_0_0, '0']
- [blocks_delay_0_0_1_0_1, '0', blocks_delay_0_1_0_0_1, '0']
- [blocks_delay_0_0_1_1, '0', blocks_delay_0_1_0_1, '0']
- [blocks_delay_0_0_1_1_0, '0', blocks_delay_0_1_0_1_0, '0']
- [blocks_delay_0_0_1_2, '0', blocks_delay_0_1_0_2, '0']
- [blocks_delay_0_0_2, '0', blocks_delay_0_1_1, '0']
- [blocks_delay_0_0_2_0, '0', blocks_delay_0_1_1_0, '0']
- [blocks_delay_0_0_2_0_0, '0', blocks_delay_0_1_1_0_0, '0']
- [blocks_delay_0_0_2_1, '0', blocks_delay_0_1_1_1, '0']
- [blocks_delay_0_0_3, '0', blocks_delay_0_1_2, '0']
- [blocks_delay_0_0_3_0, '0', blocks_delay_0_1_2_0, '0']
- [blocks_delay_0_0_4, '0', blocks_delay_0_1_3, '0']
- [blocks_delay_0_1, '0', blocks_delay_0_0_0, '0']
- [blocks_delay_0_1_0, '0', blocks_delay_0_0_0_0, '0']
- [blocks_delay_0_1_0_0, '0', blocks_delay_0_0_0_0_0, '0']
- [blocks_delay_0_1_0_0_0, '0', blocks_delay_0_0_0_0_0_0, '0']
- [blocks_delay_0_1_0_0_0_0, '0', blocks_delay_0_0_0_0_0_0_0, '0']
- [blocks_delay_0_1_0_0_1, '0', blocks_delay_0_0_0_0_0_1, '0']
- [blocks_delay_0_1_0_1, '0', blocks_delay_0_0_0_0_1, '0']
- [blocks_delay_0_1_0_1_0, '0', blocks_delay_0_0_0_0_1_0, '0']
- [blocks_delay_0_1_0_2, '0', blocks_delay_0_0_0_0_2, '0']
- [blocks_delay_0_1_1, '0', blocks_delay_0_0_0_1, '0']
- [blocks_delay_0_1_1_0, '0', blocks_delay_0_0_0_1_0, '0']
- [blocks_delay_0_1_1_0_0, '0', blocks_delay_0_0_0_1_0_0, '0']
- [blocks_delay_0_1_1_1, '0', blocks_delay_0_0_0_1_1, '0']
- [blocks_delay_0_1_2, '0', blocks_delay_0_0_0_2, '0']
- [blocks_delay_0_1_2_0, '0', blocks_delay_0_0_0_2_0, '0']
- [blocks_delay_0_1_3, '0', blocks_delay_0_0_0_3, '0']
- [blocks_delay_0_2, '0', blocks_delay_0_0_1, '0']
- [blocks_delay_0_2_0, '0', blocks_delay_0_0_1_0, '0']
- [blocks_delay_0_2_0_0, '0', blocks_delay_0_0_1_0_0, '0']
- [blocks_delay_0_2_0_0_0, '0', blocks_delay_0_0_1_0_0_0, '0']
- [blocks_delay_0_2_0_1, '0', blocks_delay_0_0_1_0_1, '0']
- [blocks_delay_0_2_1, '0', blocks_delay_0_0_1_1, '0']
- [blocks_delay_0_2_1_0, '0', blocks_delay_0_0_1_1_0, '0']
- [blocks_delay_0_2_2, '0', blocks_delay_0_0_1_2, '0']
- [blocks_delay_0_3, '0', blocks_delay_0_0_2, '0']
- [blocks_delay_0_3_0, '0', blocks_delay_0_0_2_0, '0']
- [blocks_delay_0_3_0_0, '0', blocks_delay_0_0_2_0_0, '0']
- [blocks_delay_0_3_1, '0', blocks_delay_0_0_2_1, '0']
- [blocks_delay_0_4, '0', blocks_delay_0_0_3, '0']
- [blocks_delay_0_4_0, '0', blocks_delay_0_0_3_0, '0']
- [blocks_delay_0_5, '0', blocks_delay_0_0_4, '0']
- [blocks_file_source_0_0_0, '0', blocks_add_xx_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_delay_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']

metadata:
  file_format: 1
